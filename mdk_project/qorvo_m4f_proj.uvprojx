# Keil uVision project qorvo_m4f_proj.uvprojx, settings and files
target pac25140_proj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PAC5523 Active-Semi
  pack: Active-Semi.PAC55XX.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qorvo_m4f_proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\bsp;..\sdk\boot_keil;..\sdk\cmsis_core;..\sdk\device;..\sdk\driver;..\sdk\peripheral
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group sdk
    ../sdk/boot_keil/: startup_pac_keil.s system_pac.c system_pac.h
    ../sdk/driver/: pac_driver_adc.c pac_driver_can.c pac_driver_gpio.c pac_driver_socbridge.c pac_driver_system.c pac_driver_tile_socbridge.c pac_driver_timer.c pac_driver_uart.c
  group app
    ../app/: main.c
  group bsp
    ../bsp/: bsp_gpio.c bsp_uart.c bsp_gpio.h bsp_uart.h bsp_sysclk.c bsp_sysclk.h
  group readme
    ../: readme.txt
